# Keil uVision project SingleLed.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: SingleLed
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Chip\Core;.\Chip\Library;.\User\APL;.\User\BLL;.\User\FML;.\User\OSL;.\User\HDL;.\User\HAL
  group Chip/Core
    ./Chip/Core/: STARTUP.A51
  group User/APL
    ./User/APL/: main.c
  group User/FML
    ./User/FML/: FmlSingleLed.c
  group User/HDL
    ./User/HDL/: HdlSingleLed.c
